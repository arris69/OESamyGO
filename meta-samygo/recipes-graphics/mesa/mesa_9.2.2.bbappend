# looks like we need some patches here to eliminate libudev...
EXTRA_OECONF =+ "--disable-gbm"
