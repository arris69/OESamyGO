DEPENDS = "sysfsutils"
EXTRA_OECONF += " --enable-sysfs"
