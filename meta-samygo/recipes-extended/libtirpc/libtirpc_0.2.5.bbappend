SRC_URI_append_samygo = " file://remove-des-uclibc.patch"
