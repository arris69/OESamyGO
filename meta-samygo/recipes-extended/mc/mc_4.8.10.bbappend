EXTRA_OECONF = "--with-screen=ncurses --without-gpm-mouse --without-x --without-samba  \
	--disable-rpath \
	--enable-static \
	--disable-share \
	 --disable-doxygen-doc --disable-doxygen-dot --disable-doxygen-html \
	--with-edit --disable-perl --disable-python \
	--sysconfdir=/usr/etc"

