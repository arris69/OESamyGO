FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

EXTRA_LDFLAGS += "-ltirpc"
