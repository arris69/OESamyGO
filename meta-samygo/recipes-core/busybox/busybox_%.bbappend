PROVIDES += "udev"
PROVIDES += "udev-utils"
RPROVIDES_${PN}-mdev += "udev"
RPROVIDES_${PN}-mdev += "udev-utils"
